# Repository KaiPereira/M.2-FPGA-Accelerator

File README.md:

# M.2 FPGA Hardware Accelerator Devboard

This is an M.2 2280 M-Key card I've designed that plugs into the SSD slot in your computer and provides an FPGA fabric you can interact with over PCIe. It also has a couple pins broken out and a couple connectors like micro HDMI and USB-C so you can create custom pipelines that go from peripherals, into the FPGA, directly into your computer through the high-speed PCIe. 

## Custom Features
- M.2 M-Key 2280 SSD Form Factor for PCIe programming and interfacing
- Artix 7 with 50K LUTs and 256MB RAM
- USB-to-JTAG for programming and interfacing with peripherals
- Micro HDMI and 10 pins broken out for extra functionality
- Functions as a standalone devboard or can interface with your computer
- 6 LEDs for debugging and programming
- TC2030 breakout under USB-C if you DNP USB-to-JTAG

## PCB Design

The M.2 FPGA Hardware Accelerator is an extremely high density 0.8mm, 6 layer board using the JLC06081H-2116 stackup and has a stackup of SIGNAL/GND/SIGNAL/PWR/GND/SIGNAL.

A V2 is likely going to use a custom or different stackup to reduce the trace width for the DDR3 traces so I can minimize the cross-talk further, which is an issue with the current board.

## Firmware

Firmware is unwritten because I haven't produced the boards, and it requires significant prototyping in Vivado but there is some basic skeleton software inside of the [/firmware](/firmware) folder.

## Production

I've based the board around JLCPCB production and I've included an LCSC/JLCPCB BOM inside of the [/PCB/production](/PCB/production/) folder.

It uses the JLC06081H-2116 stackup which you can find details about on the JLC site if you want to produce the board from a different fabricator.

You'll want some specific settings too like:
- Impedance controlled traces
- ENIG and select gold fingers to add hard gold onto the M.2 M-Key edge connector
- 0.8mm thick board
- X-Ray to confirm all the BGA placement

Produce this board at your own cost, it's an untested board and I haven't manufactured it myself yet, because I want to create a V2 with a different stackup, and it's an extremely constrained design so many problems can arise!  

## Credits

Thanks so much to the KiCad discord for the PCB reviews, and to everyone in Hack Club for the support and to Renran and Samliu for running [Fallout](https://fallout.hackclub.com/) which is the program that's sponsoring this project!

## KiCad design PCB/PCB.kicad_pcb

Notes on the sheet:
STATUS LED'S
For a production board: - make R8, R6, R35 and R33, 0402 and exact! - make 47nF caps 0402
Reviews on: - Reddit - EEBlog - KiCad Discord - Slack

Parts:
C87, C126, C130: 4u7; C_0603_1608Metric
C127, C129: 470n; C_0201_0603Metric
C128: 47n; C_0603_1608Metric
C131: 47u; C_1206_3216Metric
J4: TYPE-C-31-M-12; USB_C_Receptacle_HRO_TYPE-C-31-M-12; MPN TYPE-C-31-M-12; LCSC C165948
L6: 1u5; L_Sunlord_SWPA4030S; MPN SWPA4030S1R5NT; LCSC C42100
R48, R49: 5k1; R_0402_1005Metric
R65: 100k; R_0402_1005Metric
U3: TPD2EUSB30; Texas_DRT-3
U17: TPS62132; VQFN-16-1EP_3x3mm_P0.5mm_EP1.68x1.68mm_ThermalVias

Connections:
+VBUS: C87.1, C126.1, C127.1, J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS), U17.10 (VIN), U17.11 (VIN), U17.12 (VIN), U17.13 (EN)
+VBUS_3V3: C129.1, C130.1, C131.1, L6.2, R65.1, U17.14 (VOS); also elsewhere on the board
/USB to JTAG/USB_D+: J4.A6 (D+), J4.B6 (D+), U3.1 (D+); also elsewhere on the board
/USB to JTAG/USB_D-: J4.A7 (D-), J4.B7 (D-), U3.2 (D-); also elsewhere on the board
GND: C87.2, C126.2, C127.2, C128.2, C129.2, C130.2, C131.2, J4.A1 (GND), J4.A12 (GND), J4.B1 (GND), J4.B12 (GND), J4.S1 (SHIELD), R48.2, R49.2, U3.3 (GND), U17.5 (FB), U17.6 (GND), U17.7 (FSW), U17.8 (DEF), U17.15 (GND), U17.16 (GND), U17.17 (GND); also elsewhere on the board
unnamed: J4.A5 (CC1), R48.1
unnamed: J4.B5 (CC2), R49.1
unnamed: L6.1, U17.1 (SW), U17.2 (SW), U17.3 (SW)
unnamed: R65.2, U17.4 (PG)
unnamed: C128.1, U17.9 (SS/TR)

Notes on the sheet:
23.5ms start up, reduce inrush >
1.5uH & 47uF for BOM optimization

Parts:
C41, C42, C43, C44, C66, C68, C70, C147, C173: 4u7; C_0603_1608Metric
C45, C49, C51, C53: 47u; C_1206_3216Metric
C46: 1u; C_0402_1005Metric
C48: 68pF; C_0402_1005Metric
C50: 33p; C_0402_1005Metric
C52: 22pF; C_0402_1005Metric
C67, C69, C71, C112: 470n; C_0201_0603Metric
C72: 47n; C_0603_1608Metric
D4: KT-0603G; LED_0603_1608Metric; MPN KT-0805G; LCSC C2297
L1, L2, L3, L4, L5: 1u5; L_Sunlord_SWPA4030S; MPN SWPA4030S1R5NT; LCSC C42100
R4: 2k; R_0402_1005Metric
R5, R7, R9, R10, R11, R12, R13, R34: 10k; R_0402_1005Metric
R6, R35: 4k99; R_0603_1608Metric
R8: 8k2; R_0603_1608Metric
R33: 30k; R_0603_1608Metric
R77: 1k; R_0402_1005Metric
U2: MAX20029ATIA/V+; QFN-28-1EP_5x5mm_P0.5mm_EP3.25x3.25mm_ThermalVias; LCSC Part C1235515
U5: TPS2121RUXR; Texas_VQFN-HR-12_2x2.5mm_P0.5mm_ThermalVias; MPN TPS2121RUXR; LCSC C485916
U8: TPS61240DRVR; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm

Connections:
+1V0: C45.1, L1.2, U2.28 (OUTS1); also elsewhere on the board
+1V2: C48.1, C49.1, L2.2, R4.1; also elsewhere on the board
+1V5: C50.1, C51.1, L4.2, R6.1; also elsewhere on the board
+1V8: C52.1, C53.1, L3.2, R8.1; also elsewhere on the board
+3V3: C41.1, C42.1, C43.1, C44.1, C46.1, C70.1, C71.1, C112.1, C147.1, D4.2 (A), L5.1, R10.1, R11.1, R12.1, R13.1, U2.1 (EN1), U2.2 (PV1), U2.7 (PV2), U2.15 (PV3), U2.20 (PV4), U2.26 (VA), U5.1 (OUT), U5.8 (OUT), U8.4 (EN), U8.6 (VI); also elsewhere on the board
+5V: C173.1, U8.2 (VOUT), U8.3 (FB); also elsewhere on the board
+VBUS_3V3: C68.1, C69.1, U5.2 (IN2); also elsewhere on the board
+VM2_3V3: C66.1, C67.1, R35.1, U5.7 (IN1); also elsewhere on the board
/Artix 7 Banks/BUCK_PG4: R13.2, U2.23 (PG4); also elsewhere on the board
GND: C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C49.2, C51.2, C53.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, C112.2, C147.2, C173.2, R5.2, R7.2, R9.2, R33.2, R34.2, R77.2, U2.4 (PGND1), U2.5 (PGND2), U2.11 (GND), U2.17 (PGND3), U2.18 (PGND4), U2.24 (AGND), U2.25 (SYNC), U2.29 (EP), U5.3 (CP2), U5.4 (OV2), U5.5 (OV1), U5.9 (ST), U5.12 (GND), U8.1 (GND), U8.7 (GND); also elsewhere on the board
unnamed: D4.1 (K), R77.1
unnamed: R10.2, U2.9 (EN2), U2.27 (PG1)
unnamed: R11.2, U2.10 (PG2), U2.13 (EN3)
unnamed: R12.2, U2.12 (PG3), U2.21 (EN4)
unnamed: L1.1, U2.3 (LX1)
unnamed: L2.1, U2.6 (LX2)
unnamed: L3.1, U2.16 (LX3)
unnamed: L4.1, U2.19 (LX4)
unnamed: C48.2, R4.2, R5.1, U2.8 (OUTS2)
unnamed: C52.2, R8.2, R9.1, U2.14 (OUTS3)
unnamed: C50.2, R6.2, R7.1, U2.22 (OUTS4)
unnamed: R33.1, U5.10 (ILIM)
unnamed: R34.1, R35.2, U5.6 (PR1)
unnamed: C72.1, U5.11 (SS)
unnamed: L5.2, U8.5 (SW)

Notes on the sheet:
Default Switching Freq >
Divider: R1 = R2[( VOUT / 1 ) − 1] Frequency compensation: C1 = 15e-12(R2 / R1)
4.7uF per PV and 1u for VA
< 0603 footprint, and dif divider because JLC basic! <
Around 1ms ramp up - 47nF Around 3A min, 4A max current limiting
A small 5V boost converter for HDMI and other future peripherals!
SEQUENCE VCC -> 1V0 -> 1V2 -> 1V8 -> 1V5
< Default VOUT is 1V
3.18V switchover, optimal w/ 1% R >
+VM2_3V3 is the M.2 3.3V power source +VBUS_3V3 is the USB power source, bucked down This circuit ensures that USB doesn't backfeed into the M.2 connector, frying the motherboard, and also prioritizes reliable M.2 connector power if both are plugged in! Switchover is at 3.18V using PR1 voltage divi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

Parts:
C13, C172: 10n; C_0402_1005Metric
C57, C58, C59, C60, C61, C62, C63, C64, C65, C73, C74, C76, C77, C78, C79, C80, C81, C82, C83, C84, C86, C110: 100n; C_0402_1005Metric
C75: 4u7; C_0603_1608Metric
C85: 47u; C_1206_3216Metric
R16: 240; R_0402_1005Metric
R17, R18, R42: 1k; R_0402_1005Metric
R23, R28, R30: 4k7; R_0402_1005Metric
R31: 100; R_0402_1005Metric
U11: MT41J128M16JT-125:K; FBGA-96_8x14mm_Layout9x16_P0.8mm; MPN MT41J128M16JT-125:K; LCSC C426885

Connections:
+1V5: C59.1, C60.1, C61.1, C62.1, C63.1, C64.1, C65.1, C73.1, C74.1, C75.1, C76.1, C77.1, C78.1, C79.1, C80.1, C81.1, C82.1, C83.1, C84.1, C85.1, C86.1, R17.1, U11.A1 (V_{DDQ}), U11.A8 (V_{DDQ}), U11.B2 (V_{DD}), U11.C1 (V_{DDQ}), U11.C9 (V_{DDQ}), U11.D2 (V_{DDQ}), U11.D9 (V_{DD}), U11.E9 (V_{DDQ}), U11.F1 (V_{DDQ}), U11.G7 (V_{DD}), U11.H2 (V_{DDQ}), U11.H9 (V_{DDQ}), U11.K2 (V_{DD}), U11.K8 (V_{DD}), U11.N1 (V_{DD}), U11.N9 (V_{DD}), U11.R1 (V_{DD}), U11.R9 (V_{DD}); also elsewhere on the board
/Artix 7 Banks/DDR_A0: U11.N3 (A0); also elsewhere on the board
/Artix 7 Banks/DDR_A1: U11.P7 (A1); also elsewhere on the board
/Artix 7 Banks/DDR_A2: U11.P3 (A2); also elsewhere on the board
/Artix 7 Banks/DDR_A3: U11.N2 (A3); also elsewhere on the board
/Artix 7 Banks/DDR_A4: U11.P8 (A4); also elsewhere on the board
/Artix 7 Banks/DDR_A5: U11.P2 (A5); also elsewhere on the board
/Artix 7 Banks/DDR_A6: U11.R8 (A6); also elsewhere on the board
/Artix 7 Banks/DDR_A7: U11.R2 (A7); also elsewhere on the board
/Artix 7 Banks/DDR_A8: U11.T8 (A8); also elsewhere on the board
/Artix 7 Banks/DDR_A9: U11.R3 (A9); also elsewhere on the board
/Artix 7 Banks/DDR_A10: U11.L7 (A10/AP); also elsewhere on the board
/Artix 7 Banks/DDR_A11: U11.R7 (A11); also elsewhere on the board
/Artix 7 Banks/DDR_A12: U11.N7 (A12/~BC); also elsewhere on the board
/Artix 7 Banks/DDR_A13: U11.T3 (A13); also elsewhere on the board
/Artix 7 Banks/DDR_BA0: U11.M2 (BA0); also elsewhere on the board
/Artix 7 Banks/DDR_BA1: U11.N8 (BA1); also elsewhere on the board
/Artix 7 Banks/DDR_BA2: U11.M3 (BA2); also elsewhere on the board
/Artix 7 Banks/DDR_CKE: R30.1, U11.K9 (CKE); also elsewhere on the board
/Artix 7 Banks/DDR_CLK+: R31.1, U11.J7 (CK); also elsewhere on the board
/Artix 7 Banks/DDR_CLK-: R31.2, U11.K7 (~CK); also elsewhere on the board
/Artix 7 Banks/DDR_DQ0: U11.E3 (DQ0); also elsewhere on the board
/Artix 7 Banks/DDR_DQ1: U11.F7 (DQ1); also elsewhere on the board
/Artix 7 Banks/DDR_DQ2: U11.F2 (DQ2); also elsewhere on the board
/Artix 7 Banks/DDR_DQ3: U11.F8 (DQ3); also elsewhere on the board
/Artix 7 Banks/DDR_DQ4: U11.H3 (DQ4); also elsewhere on the board
/Artix 7 Banks/DDR_DQ5: U11.H8 (DQ5); also elsewhere on the board
/Artix 7 Banks/DDR_DQ6: U11.G2 (DQ6); also elsewhere on the board
/Artix 7 Banks/DDR_DQ7: U11.H7 (DQ7); also elsewhere on the board
/Artix 7 Banks/DDR_DQ8: U11.D7 (DQ8); also elsewhere on the board
/Artix 7 Banks/DDR_DQ9: U11.C3 (DQ9); also elsewhere on the board
/Artix 7 Banks/DDR_DQ10: U11.C8 (DQ10); also elsewhere on the board
/Artix 7 Banks/DDR_DQ11: U11.C2 (DQ11); also elsewhere on the board
/Artix 7 Banks/DDR_DQ12: U11.A7 (DQ12); also elsewhere on the board
/Artix 7 Banks/DDR_DQ13: U11.A2 (DQ13); also elsewhere on the board
/Artix 7 Banks/DDR_DQ14: U11.B8 (DQ14); also elsewhere on the board
/Artix 7 Banks/DDR_DQ15: U11.A3 (DQ15); also elsewhere on the board
/Artix 7 Banks/DDR_DQM0: U11.E7 (LDM); also elsewhere on the board
/Artix 7 Banks/DDR_DQM1: U11.D3 (UDM); also elsewhere on the board
/Artix 7 Banks/DDR_DQS0+: U11.F3 (LDQS); also elsewhere on the board
/Artix 7 Banks/DDR_DQS0-: U11.G3 (~LDQS); also elsewhere on the board
/Artix 7 Banks/DDR_DQS1+: U11.C7 (UDQS); also elsewhere on the board
/Artix 7 Banks/DDR_DQS1-: U11.B7 (~UDQS); also elsewhere on the board
/Artix 7 Banks/~DDR_CAS: U11.K3 (~CAS); also elsewhere on the board
/Artix 7 Banks/~DDR_ODT: R23.1, U11.K1 (ODT); also elsewhere on the board
/Artix 7 Banks/~DDR_RAS: U11.J3 (~RAS); also elsewhere on the board
/Artix 7 Banks/~DDR_RESET: R28.1, U11.T2 (~RESET); also elsewhere on the board
/Artix 7 Banks/~DDR_WE: U11.L3 (~WE); also elsewhere on the board
GND: C13.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C73.2, C74.2, C75.2, C76.2, C77.2, C78.2, C79.2, C80.2, C81.2, C82.2, C83.2, C84.2, C85.2, C110.2, C172.2, R16.2, R18.2, R23.2, R28.2, R30.2, R42.1, U11.A9 (V_{SS}), U11.B1 (V_{SSQ}), U11.B3 (V_{SS}), U11.B9 (V_{SSQ}), U11.D1 (V_{SSQ}), U11.D8 (V_{SSQ}), U11.E1 (V_{SS}), U11.E2 (V_{SSQ}), U11.E8 (V_{SSQ}), U11.F9 (V_{SSQ}), U11.G1 (V_{SSQ}), U11.G8 (V_{SS}), U11.G9 (V_{SSQ}), U11.J2 (V_{SS}), U11.J8 (V_{SS}), U11.M1 (V_{SS}), U11.M9 (V_{SS}), U11.P1 (V_{SS}), U11.P9 (V_{SS}), U11.T1 (V_{SS}), U11.T9 (V_{SS}); also elsewhere on the board
unnamed: C13.1, C57.1, C58.1, C86.2, C110.1, C172.1, R17.2, R18.1, U11.H1 (V_{REFDQ}), U11.M8 (V_{REFCA})
unnamed: R16.1, U11.L8 (ZQ)
unnamed: R42.2, U11.L2 (~CS)

Notes on the sheet:
MT41J128M16JT-125:K 16 Bit data width 8 Bank machines Normal ordering
< 0.75V reference, needs to be very precise!
33mm, byte lane 1
Shunt termination because CLK doesn't have ODT :(
30mm, byte lane 2
100nF per pin and then a 47u and 4u7 cap for bulk and to minimize space! It's honestly a bad layout on the board because the caps are only on one side, but it's fine :/

Parts:
C2, C15: 4u7; C_0603_1608Metric
C3, C4, C5, C6, C7, C8, C9, C10, C11, C12: 220n; C_0402_1005Metric
J1: Bus_M.2_Edge_M; M.2 M-Key 2242
R25, R26: 22; R_0402_1005Metric

Connections:
+VM2_3V3: C2.1, C15.1, J1.2 (3.3V), J1.4 (3.3V), J1.12 (3.3V), J1.14 (3.3V), J1.16 (3.3V), J1.18 (3.3V), J1.70 (3.3V), J1.72 (3.3V), J1.74 (3.3V); also elsewhere on the board
/Artix 7 Banks/~PCIe_CLKREQ: R26.1; also elsewhere on the board
/Artix 7 Banks/~PCIe_PERST: J1.50 (~PERST); also elsewhere on the board
/Artix 7 Banks/~PCIe_PEWAKE: R25.1; also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_REFCLK+: C11.1; also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_REFCLK-: C12.1; also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_RX0+: J1.49 (PERp0/SATA-A+); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_RX0-: J1.47 (PERn0/SATA-A-); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_RX1+: J1.37 (PERp1); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_RX1-: J1.35 (PERn1); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_RX2+: J1.25 (PERp2); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_RX2-: J1.23 (PERn2); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_RX3+: J1.13 (PERp3); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_RX3-: J1.11 (PERn3); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_TX0+: C3.1; also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_TX0-: C4.1; also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_TX1+: C5.1; also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_TX1-: C6.1; also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_TX2+: C7.1; also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_TX2-: C8.1; also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_TX3+: C9.1; also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_TX3-: C10.1; also elsewhere on the board
/M.2 M-Key Edge Connector/PCIe_M2_REFCLK+: C11.2, J1.55 (REFCLKp)
/M.2 M-Key Edge Connector/PCIe_M2_REFCLK-: C12.2, J1.53 (REFCLKn)
/M.2 M-Key Edge Connector/PCIe_M2_TX0+: C3.2, J1.43 (PETp0/SATA-B-)
/M.2 M-Key Edge Connector/PCIe_M2_TX0-: C4.2, J1.41 (PETn0/SATA-B+)
/M.2 M-Key Edge Connector/PCIe_M2_TX1+: C5.2, J1.31 (PETp1)
/M.2 M-Key Edge Connector/PCIe_M2_TX1-: C6.2, J1.29 (PETn1)
/M.2 M-Key Edge Connector/PCIe_M2_TX2+: C7.2, J1.19 (PETp2)
/M.2 M-Key Edge Connector/PCIe_M2_TX2-: C8.2, J1.17 (PETn2)
/M.2 M-Key Edge Connector/PCIe_M2_TX3+: C9.2, J1.7 (PETp3)
/M.2 M-Key Edge Connector/PCIe_M2_TX3-: C10.2, J1.5 (PETn3)
GND: C2.2, C15.2, J1.1 (GND), J1.3 (GND), J1.9 (GND), J1.15 (GND), J1.21 (GND), J1.27 (GND), J1.33 (GND), J1.39 (GND), J1.45 (GND), J1.51 (GND), J1.57 (GND), J1.71 (GND), J1.73 (GND), J1.75 (GND); also elsewhere on the board
unnamed: J1.52 (~CLKREQ), R26.2
unnamed: J1.54 (~PEWAKE), R25.2

Notes on the sheet:
Transmiting (TX) FROM the FPGA TO the host Receiving (RX) FROM the host TO the FPGA >
Dampening for long, slow traces >
< Don't need low power states
< Dampening for inrush for each group My power OR controller acts as the third
I inverted the bus symbol, to create an edge connector symbol DOUBLE CHECK the transmit/receive are the right orientation!! Pg 150, https://picture.iczhiku.com/resource/eetop/sHksKPigIJigRbbx.pdf All the NC's are SATA only features! AC Coupling should be near the edge connector to reduce impedance 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

Parts:
U1: XC7A50T-FGG484; Xilinx_FGG484

Connections:
/Artix 7 PCIe GTP Transceivers/PCIe_REFCLK+: U1.F6 (MGTREFCLK0P_216); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_REFCLK-: U1.E6 (MGTREFCLK0N_216); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_RX0+: U1.B8 (MGTPRXP0_216); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_RX0-: U1.A8 (MGTPRXN0_216); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_RX1+: U1.D11 (MGTPRXP1_216); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_RX1-: U1.C11 (MGTPRXN1_216); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_RX2+: U1.B10 (MGTPRXP2_216); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_RX2-: U1.A10 (MGTPRXN2_216); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_RX3+: U1.D9 (MGTPRXP3_216); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_RX3-: U1.C9 (MGTPRXN3_216); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_TX0+: U1.B4 (MGTPTXP0_216); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_TX0-: U1.A4 (MGTPTXN0_216); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_TX1+: U1.D5 (MGTPTXP1_216); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_TX1-: U1.C5 (MGTPTXN1_216); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_TX2+: U1.B6 (MGTPTXP2_216); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_TX2-: U1.A6 (MGTPTXN2_216); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_TX3+: U1.D7 (MGTPTXP3_216); also elsewhere on the board
/Artix 7 PCIe GTP Transceivers/PCIe_TX3-: U1.C7 (MGTPTXN3_216); also elsewhere on the board

Notes on the sheet:
Double check clock pins >
