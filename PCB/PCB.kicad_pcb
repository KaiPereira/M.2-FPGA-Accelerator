# Repository KaiPereira/M.2-FPGA-Accelerator (continued)

## KiCad design PCB/PCB.kicad_pcb (continued)

Parts:
C88, C132, C140, C149, C158, C165: 47u; C_1206_3216Metric
C89, C90, C133, C134, C141, C142, C152, C153, C159, C160, C166, C167: 4u7; C_0603_1608Metric
C91, C92, C124, C125, C135, C136, C137, C138, C143, C144, C145, C146, C154, C155, C156, C157, C161, C162, C163, C164, C168, C169, C170, C171: 470n; C_0201_0603Metric
C139: 100n; C_0402_1005Metric
D5, D6, D7: KT-0603G; LED_0603_1608Metric; MPN KT-0805G; LCSC C2297
J5: Conn_02x05_Odd_Even; PinHeader_2x05_P1.27mm_Vertical_SMD
R43, R78, R79, R80: 1k; R_0402_1005Metric
R45, R46, R50: 10k; R_0402_1005Metric
R75: 22; R_0402_1005Metric
U1: XC7A50T-FGG484; Xilinx_FGG484
Y3: 100MHz; Oscillator_SMD_SiT_PQFN-4Pin_5.0x3.2mm; MPN SIT8008BI-32-33E-100.000000; LCSC C78882

Connections:
+1V5: C149.1, C152.1, C153.1, C154.1, C155.1, C156.1, C157.1, C158.1, C159.1, C160.1, C161.1, C162.1, C163.1, C164.1, U1.AA7 (VCCO_34), U1.AB4 (VCCO_34), U1.C1 (VCCO_35), U1.F2 (VCCO_35), U1.H6 (VCCO_35), U1.J3 (VCCO_35), U1.M4 (VCCO_35), U1.N1 (VCCO_35), U1.R5 (VCCO_34), U1.T2 (VCCO_34), U1.V6 (VCCO_34), U1.W3 (VCCO_34); also elsewhere on the board
+3V3: C88.1, C89.1, C90.1, C91.1, C92.1, C124.1, C125.1, C132.1, C133.1, C134.1, C135.1, C136.1, C137.1, C138.1, C139.1, C140.1, C141.1, C142.1, C143.1, C144.1, C145.1, C146.1, C165.1, C166.1, C167.1, C168.1, C169.1, C170.1, C171.1, J5.9, R43.1, R45.1, R46.1, R50.1, U1.A17 (VCCO_16), U1.AA17 (VCCO_13), U1.AB14 (VCCO_13), U1.B14 (VCCO_16), U1.C21 (VCCO_16), U1.D18 (VCCO_16), U1.E15 (VCCO_16), U1.F22 (VCCO_16), U1.G19 (VCCO_15), U1.H16 (VCCO_15), U1.J13 (VCCO_15), U1.K20 (VCCO_15), U1.L17 (VCCO_15), U1.M14 (VCCO_14), U1.N21 (VCCO_15), U1.P18 (VCCO_14), U1.R15 (VCCO_14), U1.T22 (VCCO_14), U1.U19 (VCCO_14), U1.V16 (VCCO_13), U1.W13 (VCCO_13), U1.Y10 (VCCO_13), U1.Y20 (VCCO_14), Y3.4 (Vdd); also elsewhere on the board
+5V: J5.1; also elsewhere on the board
/Artix 7 Banks/BUCK_PG4: Y3.1 (OE); also elsewhere on the board
/Artix 7 Banks/CLK_100MHz: R75.2, U1.W20 (IO_L12N_T1_MRCC_14)
/Artix 7 Banks/DDR_A0: U1.AB2 (IO_L8N_T1_34); also elsewhere on the board
/Artix 7 Banks/DDR_A1: U1.Y1 (IO_L5N_T0_34); also elsewhere on the board
/Artix 7 Banks/DDR_A2: U1.W1 (IO_L5P_T0_34); also elsewhere on the board
/Artix 7 Banks/DDR_A3: U1.Y2 (IO_L4N_T0_34); also elsewhere on the board
/Artix 7 Banks/DDR_A4: U1.R2 (IO_L3N_T0_DQS_34); also elsewhere on the board
/Artix 7 Banks/DDR_A5: U1.AB3 (IO_L8P_T1_34); also elsewhere on the board
/Artix 7 Banks/DDR_A6: U1.U2 (IO_L2P_T0_34); also elsewhere on the board
/Artix 7 Banks/DDR_A7: U1.W2 (IO_L4P_T0_34); also elsewhere on the board
/Artix 7 Banks/DDR_A8: U1.T1 (IO_L1P_T0_34); also elsewhere on the board
/Artix 7 Banks/DDR_A9: U1.AB1 (IO_L7N_T1_34); also elsewhere on the board
/Artix 7 Banks/DDR_A10: U1.R3 (IO_L3P_T0_DQS_34); also elsewhere on the board
/Artix 7 Banks/DDR_A11: U1.U1 (IO_L1N_T0_34); also elsewhere on the board
/Artix 7 Banks/DDR_A12: U1.V4 (IO_L12P_T1_MRCC_34); also elsewhere on the board
/Artix 7 Banks/DDR_A13: U1.AA1 (IO_L7P_T1_34); also elsewhere on the board
/Artix 7 Banks/DDR_BA0: U1.AA5 (IO_L10P_T1_34); also elsewhere on the board
/Artix 7 Banks/DDR_BA1: U1.W4 (IO_L12N_T1_MRCC_34); also elsewhere on the board
/Artix 7 Banks/DDR_BA2: U1.AB5 (IO_L10N_T1_34); also elsewhere on the board
/Artix 7 Banks/DDR_CKE: U1.V3 (IO_L6N_T0_VREF_34); also elsewhere on the board
/Artix 7 Banks/DDR_CLK+: U1.Y3 (IO_L9P_T1_DQS_34); also elsewhere on the board
/Artix 7 Banks/DDR_CLK-: U1.AA3 (IO_L9N_T1_DQS_34); also elsewhere on the board
/Artix 7 Banks/DDR_DQ0: U1.Y6 (IO_L18P_T2_34); also elsewhere on the board
/Artix 7 Banks/DDR_DQ1: U1.T5 (IO_L14P_T2_SRCC_34); also elsewhere on the board
/Artix 7 Banks/DDR_DQ2: U1.U5 (IO_L14N_T2_SRCC_34); also elsewhere on the board
/Artix 7 Banks/DDR_DQ3: U1.U6 (IO_L16P_T2_34); also elsewhere on the board
/Artix 7 Banks/DDR_DQ4: U1.T4 (IO_L13N_T2_MRCC_34); also elsewhere on the board
/Artix 7 Banks/DDR_DQ5: U1.AA6 (IO_L18N_T2_34); also elsewhere on the board
/Artix 7 Banks/DDR_DQ6: U1.R4 (IO_L13P_T2_MRCC_34); also elsewhere on the board
/Artix 7 Banks/DDR_DQ7: U1.R6 (IO_L17P_T2_34); also elsewhere on the board
/Artix 7 Banks/DDR_DQ8: U1.Y7 (IO_L23N_T3_34); also elsewhere on the board
/Artix 7 Banks/DDR_DQ9: U1.AB8 (IO_L22N_T3_34); also elsewhere on the board
/Artix 7 Banks/DDR_DQ10: U1.Y8 (IO_L23P_T3_34); also elsewhere on the board
/Artix 7 Banks/DDR_DQ11: U1.W9 (IO_L24P_T3_34); also elsewhere on the board
/Artix 7 Banks/DDR_DQ12: U1.Y9 (IO_L24N_T3_34); also elsewhere on the board
/Artix 7 Banks/DDR_DQ13: U1.AB7 (IO_L20P_T3_34); also elsewhere on the board
/Artix 7 Banks/DDR_DQ14: U1.W7 (IO_L19N_T3_VREF_34); also elsewhere on the board
/Artix 7 Banks/DDR_DQ15: U1.AA8 (IO_L22P_T3_34); also elsewhere on the board
/Artix 7 Banks/DDR_DQM0: U1.T6 (IO_L17N_T2_34); also elsewhere on the board
/Artix 7 Banks/DDR_DQM1: U1.V7 (IO_L19P_T3_34); also elsewhere on the board
/Artix 7 Banks/DDR_DQS0+: U1.W6 (IO_L15P_T2_DQS_34); also elsewhere on the board
/Artix 7 Banks/DDR_DQS0-: U1.W5 (IO_L15N_T2_DQS_34); also elsewhere on the board
/Artix 7 Banks/DDR_DQS1+: U1.V9 (IO_L21P_T3_DQS_34); also elsewhere on the board
/Artix 7 Banks/DDR_DQS1-: U1.V8 (IO_L21N_T3_DQS_34); also elsewhere on the board
/Artix 7 Banks/GPIO_0: J5.2, U1.D21 (IO_L23N_T3_16)
/Artix 7 Banks/GPIO_1: J5.3, U1.F15 (IO_0_16)
/Artix 7 Banks/GPIO_2: J5.4, U1.C22 (IO_L20P_T3_16)
/Artix 7 Banks/GPIO_3: J5.5, U1.F16 (IO_L2P_T0_16)
/Artix 7 Banks/GPIO_4: J5.6, U1.C20 (IO_L19N_T3_VREF_16)
/Artix 7 Banks/GPIO_5: J5.8, U1.D22 (IO_L22N_T3_16)
/Artix 7 Banks/GPIO_6: J5.10, U1.B22 (IO_L20N_T3_16)
/Artix 7 Banks/HDMI_CEC: U1.A18 (IO_L17P_T2_16); also elsewhere on the board
/Artix 7 Banks/HDMI_CLK+: U1.B16 (IO_L7N_T1_16); also elsewhere on the board
/Artix 7 Banks/HDMI_CLK-: U1.B17 (IO_L11P_T1_SRCC_16); also elsewhere on the board
/Artix 7 Banks/HDMI_D0+: U1.A15 (IO_L9P_T1_DQS_16); also elsewhere on the board
/Artix 7 Banks/HDMI_D0-: U1.A16 (IO_L9N_T1_DQS_16); also elsewhere on the board
/Artix 7 Banks/HDMI_D1+: U1.B15 (IO_L7P_T1_16); also elsewhere on the board
/Artix 7 Banks/HDMI_D1-: U1.A14 (IO_L10N_T1_16); also elsewhere on the board
/Artix 7 Banks/HDMI_D2+: U1.A13 (IO_L10P_T1_16); also elsewhere on the board
/Artix 7 Banks/HDMI_D2-: U1.B13 (IO_L8N_T1_16); also elsewhere on the board
/Artix 7 Banks/HDMI_HPD: U1.A19 (IO_L17N_T2_16); also elsewhere on the board
/Artix 7 Banks/HDMI_SCL: U1.A21 (IO_L21N_T3_DQS_16); also elsewhere on the board
/Artix 7 Banks/HDMI_SDA: U1.A20 (IO_L16N_T2_16); also elsewhere on the board
/Artix 7 Banks/QSPI_CS: U1.T19 (IO_L6P_T0_FCS_B_14); also elsewhere on the board
/Artix 7 Banks/QSPI_DQ0: U1.P22 (IO_L1P_T0_D00_MOSI_14); also elsewhere on the board
/Artix 7 Banks/QSPI_DQ1: U1.R22 (IO_L1N_T0_D01_DIN_14); also elsewhere on the board
/Artix 7 Banks/QSPI_DQ2: U1.P21 (IO_L2P_T0_D02_14); also elsewhere on the board
/Artix 7 Banks/QSPI_DQ3: U1.R21 (IO_L2N_T0_D03_14); also elsewhere on the board
/Artix 7 Banks/UART_RXD: U1.AB22 (IO_L10N_T1_D15_14); also elsewhere on the board
/Artix 7 Banks/UART_TXD: U1.V20 (IO_L11N_T1_SRCC_14); also elsewhere on the board
/Artix 7 Banks/USER_LED_1: R78.1, U1.C19 (IO_L13N_T2_MRCC_16)
/Artix 7 Banks/USER_LED_2: R79.1, U1.F13 (IO_L1P_T0_16)
/Artix 7 Banks/USER_LED_3: R80.1, U1.C13 (IO_L8P_T1_16)
/Artix 7 Banks/~DDR_CAS: U1.Y4 (IO_L11P_T1_SRCC_34); also elsewhere on the board
/Artix 7 Banks/~DDR_ODT: U1.V2 (IO_L2N_T0_34); also elsewhere on the board
/Artix 7 Banks/~DDR_RAS: U1.U3 (IO_L6P_T0_34); also elsewhere on the board
/Artix 7 Banks/~DDR_RESET: U1.T3 (IO_0_34); also elsewhere on the board
/Artix 7 Banks/~DDR_WE: U1.AA4 (IO_L11N_T1_SRCC_34); also elsewhere on the board
/Artix 7 Banks/~PCIe_CLKREQ: R50.2, U1.P17 (IO_L21N_T3_DQS_A06_D22_14); also elsewhere on the board
/Artix 7 Banks/~PCIe_PERST: R45.2, U1.P16 (IO_L24P_T3_A01_D17_14); also elsewhere on the board
/Artix 7 Banks/~PCIe_PEWAKE: R46.2, U1.N17 (IO_L21P_T3_DQS_14); also elsewhere on the board
GND: C88.2, C89.2, C90.2, C91.2, C92.2, C124.2, C125.2, C132.2, C133.2, C134.2, C135.2, C136.2, C137.2, C138.2, C139.2, C140.2, C141.2, C142.2, C143.2, C144.2, C145.2, C146.2, C149.2, C152.2, C153.2, C154.2, C155.2, C156.2, C157.2, C158.2, C159.2, C160.2, C161.2, C162.2, C163.2, C164.2, C165.2, C166.2, C167.2, C168.2, C169.2, C170.2, C171.2, D5.1 (K), D6.1 (K), D7.1 (K), J5.7, Y3.2 (GND); also elsewhere on the board
unnamed: D5.2 (A), R78.2
unnamed: D6.2 (A), R79.2
unnamed: D7.2 (A), R80.2
unnamed: R43.2, U1.U22 (IO_L3P_T0_DQS_PUDC_B_14)
unnamed: R75.1, Y3.3 (OUT)

Notes on the sheet:
Most of the NC's are usable as I/O's too, even if they're configurations ;)
47u + 2x 4u7 + 4x 470n capacitors per bank!
< Can change to different pins if needed, just pin optimizing
Wait for rails before starting the crystal! >
< TXD to the FPGA, RXD to the FT2232H
Pull HIGH = disable internal I/O pullups Pull LOW = enable internal I/O pullups

Parts:
C93: 100n; C_0402_1005Metric
C94, C98, C101, C103: 4u7; C_0603_1608Metric
C95, C99, C100, C102, C104, C105, C106, C107, C108, C109: 470n; C_0201_0603Metric
C96, C97: 33p; C_0402_1005Metric
D2: KT-0805Y; LED_0805_2012Metric; MPN KT-0805Y; LCSC C2296
J2: Conn_ARM_SWD_TagConnect_TC2030; Tag-Connect_TC2030-IDC-FP_2x03_P1.27mm_Vertical
R29, R32, R36, R37: 22; R_0402_1005Metric
R38, R39, R40, R41, R51, R53, R54: 10k; R_0402_1005Metric
R52: 2k2; R_0402_1005Metric
R55: 12k; R_0402_1005Metric
R56, R76: 1k; R_0402_1005Metric
U4, U6: TPD2EUSB30; Texas_DRT-3
U9: M93C56-WMN6TP; SOIC-8_3.9x4.9mm_P1.27mm
U10: FT2232HQ; QFN-64-1EP_9x9mm_P0.5mm_EP4.35x4.35mm
Y2: 12MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; MPN X322512MSB4SI; LCSC C9002

Connections:
+3V3: C93.2, C94.1, C95.1, C101.1, C103.1, C104.1, C105.1, C106.1, C107.1, C108.1, C109.1, D2.2 (A), J2.1 (VCC), R38.1, R39.1, R40.1, R41.1, R51.1, R53.1, R54.1, R56.1, U9.6 (ORG), U9.8 (VCC), U10.4 (VPHY), U10.9 (VPLL), U10.20 (VCCIO), U10.31 (VCCIO), U10.42 (VCCIO), U10.50 (VREGIN), U10.56 (VCCIO); also elsewhere on the board
/Artix 7 Banks/UART_RXD: U10.39 (BDBUS1); also elsewhere on the board
/Artix 7 Banks/UART_TXD: U10.38 (BDBUS0); also elsewhere on the board
/Artix 7 Configurations and Flash/JTAG_TCK: R29.2, R38.2; also elsewhere on the board
/Artix 7 Configurations and Flash/JTAG_TDI: R32.2, R39.2; also elsewhere on the board
/Artix 7 Configurations and Flash/JTAG_TDO: R36.2, R40.2; also elsewhere on the board
/Artix 7 Configurations and Flash/JTAG_TMS: R37.2, R41.2; also elsewhere on the board
/USB to JTAG/1V8_INTERNAL_LDO: C98.1, C99.1, C100.1, C102.1, U10.12 (VCORE), U10.37 (VCORE), U10.49 (VREGOUT), U10.64 (VCORE)
/USB to JTAG/USB_D+: U10.8 (DP); also elsewhere on the board
/USB to JTAG/USB_D-: U10.7 (DM); also elsewhere on the board
GND: C93.1, C94.2, C95.2, C96.1, C97.1, C98.2, C99.2, C100.2, C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C108.2, C109.2, J2.5 (GND), R55.1, U4.3 (GND), U6.3 (GND), U9.5 (GND), U10.1 (GND), U10.5 (GND), U10.10 (AGND), U10.11 (GND), U10.13 (TEST), U10.15 (GND), U10.25 (GND), U10.35 (GND), U10.47 (GND), U10.51 (GND), U10.65 (GND), Y2.2, Y2.4; also elsewhere on the board
unnamed: D2.1 (K), R76.2
unnamed: J2.4 (SWCLK/TCK), R29.1, U4.2 (D-), U10.16 (ADBUS0)
unnamed: J2.2 (SWDIO/TMS), R37.1, U4.1 (D+), U10.19 (ADBUS3)
unnamed: J2.6 (SWO/TDO), R36.1, U6.2 (D-), U10.18 (ADBUS2)
unnamed: J2.3 (~RESET), R32.1, U6.1 (D+), U10.17 (ADBUS1)
unnamed: R51.2, R52.1, U9.4 (DO)
unnamed: R76.1, U10.54 (BCBUS3), U10.55 (BCBUS4)
unnamed: R53.2, U9.2 (SCLK), U10.62 (EECLK)
unnamed: R54.2, U9.1 (CS), U10.63 (EECS)
unnamed: R52.2, U9.3 (DI), U10.61 (EEDATA)
unnamed: C96.2, U10.2 (OSCI), Y2.3
unnamed: C97.2, U10.3 (OSCO), Y2.1
unnamed: R55.2, U10.6 (REF)
unnamed: R56.2, U10.14 (~RESET)

Notes on the sheet:
Only have one plugged in at once!

Schematic: FPGA-power.kicad_sch

Parts:
C17, C18, C19, C20, C25, C27, C28, C29, C30, C31, C35, C36, C38, C39, C47, C54, C118, C148: 470n; C_0201_0603Metric
C21, C22, C23, C32, C33, C37, C40, C56: 4u7; C_0603_1608Metric
C24: 330u; CP_EIA-3528-21_Kemet-B; MPN ETPE330MA9GB; LCSC C542287
C26: 100u; C_1206_3216Metric; MPN CL31A107MQHNNNE; LCSC C15008
C34: 47u; C_1206_3216Metric
FB1: 120@100MHz; L_0805_2012Metric; MPN 742792023; LCSC C5120901
R1: 100; R_0402_1005Metric
U1: XC7A50T-FGG484; Xilinx_FGG484

Connections:
+1V0: C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C56.1, C118.1, C148.1, FB1.1, U1.H8 (VCCINT), U1.H10 (VCCINT), U1.J7 (VCCINT), U1.J9 (VCCINT), U1.J11 (VCCBRAM), U1.K8 (VCCINT), U1.L7 (VCCINT), U1.L11 (VCCBRAM), U1.M8 (VCCINT), U1.N7 (VCCINT), U1.N11 (VCCBRAM), U1.P8 (VCCINT), U1.P10 (VCCINT), U1.R7 (VCCINT), U1.R9 (VCCINT), U1.T8 (VCCINT), U1.T10 (VCCINT); also elsewhere on the board
+1V2: C38.1, C39.1, C40.1, R1.2, U1.B5 (MGTAVTT), U1.B7 (MGTAVTT), U1.B9 (MGTAVTT), U1.B11 (MGTAVTT), U1.C4 (MGTAVTT), U1.C8 (MGTAVTT); also elsewhere on the board
+1V8: C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C47.1, C54.1, U1.E12 (VCCBATT_0), U1.H12 (VCCAUX), U1.K10 (VCCADC_0), U1.K12 (VCCAUX), U1.M12 (VCCAUX), U1.P12 (VCCAUX), U1.R11 (VCCAUX); also elsewhere on the board
GND: C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C47.2, C54.2, C56.2, C118.2, C148.2, U1.A2 (GND), U1.A3 (GND), U1.A5 (GND), U1.A7 (GND), U1.A9 (GND), U1.A11 (GND), U1.A12 (GND), U1.A22 (GND), U1.AA2 (GND), U1.AA12 (GND), U1.AA22 (GND), U1.AB9 (GND), U1.AB19 (GND), U1.B3 (GND), U1.B12 (GND), U1.B19 (GND), U1.C3 (GND), U1.C6 (GND), U1.C10 (GND), U1.C12 (GND), U1.C16 (GND), U1.D3 (GND), U1.D4 (GND), U1.D8 (GND), U1.D12 (GND), U1.D13 (GND), U1.E4 (GND), U1.E5 (GND), U1.E7 (GND), U1.E9 (GND), U1.E11 (GND), U1.E20 (GND), U1.F5 (GND), U1.F11 (GND), U1.F17 (GND), U1.G5 (GND), U1.G6 (GND), U1.G7 (GND), U1.G8 (GND), U1.G9 (GND), U1.G10 (GND), U1.G12 (GND), U1.G14 (GND), U1.H1 (GND), U1.H7 (GND), U1.H9 (GND), U1.H11 (GND), U1.H21 (GND), U1.J8 (GND), U1.J10 (GND), U1.J12 (GND)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; also elsewhere on the board
unnamed: C35.1, C36.1, C37.1, FB1.2, U1.D6 (MGTAVCC), U1.D10 (MGTAVCC), U1.E8 (MGTAVCC), U1.F7 (MGTAVCC), U1.F9 (MGTAVCC)
unnamed: R1.1, U1.F8 (MGTRREF_216)

Notes on the sheet:
No ferrite bead because low impedance termination rail!
Remember to model pi filter!
Simulate beads in LTSpice!
Maybe a ferrite bead on VCCADC >

Schematic: hdmi.kicad_sch

Parts:
C14, C16, C113, C114, C115, C116, C117, C119, C120, C122, C123: 100n; C_0402_1005Metric
C121: 1u; C_0402_1005Metric
D3: 1N5819WS; D_SOD-323; MPN 1N5819WS
J7: HDMI_D_1.4; Kai's_HDMI_Micro-D_Molex_46765-1xxx; MPN HYC23-HDMID19-650; LCSC C711358
R47: 30k; R_0603_1608Metric
R57: 1k; R_0402_1005Metric
R58: 100k; R_0402_1005Metric
R59, R60, R61, R62: 4k7; R_0402_1005Metric
U12: PCA9306DC1; VSSOP-8_2.3x2mm_P0.5mm; MPN PCA9306DC1; LCSC C129510
U14, U15, U16: UCL0524P; Diodes_UDFN-10_1.0x2.5mm_P0.5mm; MPN UCL0524P; LCSC C2835428

Connections:
+3V3: C123.1, R47.1, R61.1, R62.1, U12.2 (VREF1); also elsewhere on the board
+5V: D3.2 (A), R58.1, R59.1, R60.1; also elsewhere on the board
/Artix 7 Banks/HDMI_CEC: J7.15 (CEC), R47.2, U14.4, U14.7; also elsewhere on the board
/Artix 7 Banks/HDMI_CLK+: C16.1; also elsewhere on the board
/Artix 7 Banks/HDMI_CLK-: C14.1; also elsewhere on the board
/Artix 7 Banks/HDMI_D0+: C116.1; also elsewhere on the board
/Artix 7 Banks/HDMI_D0-: C115.1; also elsewhere on the board
/Artix 7 Banks/HDMI_D1+: C114.1; also elsewhere on the board
/Artix 7 Banks/HDMI_D1-: C113.1; also elsewhere on the board
/Artix 7 Banks/HDMI_D2+: C119.1; also elsewhere on the board
/Artix 7 Banks/HDMI_D2-: C117.1; also elsewhere on the board
/Artix 7 Banks/HDMI_HPD: R57.1; also elsewhere on the board
/Artix 7 Banks/HDMI_SCL: R62.2, U12.4 (SDA1); also elsewhere on the board
/Artix 7 Banks/HDMI_SDA: R61.2, U12.3 (SCL1); also elsewhere on the board
/HDMI/HDMI_CONN_CLK+: C16.2, J7.12 (CK+), U16.4, U16.7
/HDMI/HDMI_CONN_CLK-: C14.2, J7.14 (CK-), U16.5, U16.6
/HDMI/HDMI_CONN_D0+: C116.2, J7.9 (D0+), U15.4, U15.7
/HDMI/HDMI_CONN_D0-: C115.2, J7.11 (D0-), U15.5, U15.6
/HDMI/HDMI_CONN_D1+: C114.2, J7.6 (D1+), U16.1, U16.10
/HDMI/HDMI_CONN_D1-: C113.2, J7.8 (D1-), U16.2, U16.9
/HDMI/HDMI_CONN_D2+: C119.2, J7.3 (D2+), U15.1, U15.10
/HDMI/HDMI_CONN_D2-: C117.2, J7.5 (D2-), U15.2, U15.9
/HDMI/HDMI_SCL_5V: J7.17 (SCL), R59.2, U12.5 (SDA2), U14.2, U14.9
/HDMI/HDMI_SDA_5V: J7.18 (SDA), R60.2, U12.6 (SCL2), U14.1, U14.10
GND: C120.2, C121.2, C122.2, C123.2, J7.4 (D2S), J7.7 (D1S), J7.10 (D0S), J7.13 (CKS), J7.16 (GND), J7.SH, U12.1 (GND), U14.3, U14.8, U15.3, U15.8, U16.3, U16.8; also elsewhere on the board
unnamed: C120.1, C121.1, D3.1 (K), J7.19 (+5V)
unnamed: J7.1 (HPD/HEAC-), R57.2, U14.5, U14.6
unnamed: C122.1, R58.2, U12.7 (VREF2), U12.8 (EN)

Notes on the sheet:
Current limit resistor!

Schematic: configurations.kicad_sch

Parts:
C111: 100n; C_0402_1005Metric
C150, C151: 470n; C_0201_0603Metric
D1: KT-0603R; LED_0603_1608Metric; MPN KT-0805Y; LCSC C2296
R2, R3, R14, R24: 1k; R_0402_1005Metric
R15: 1k; R_0402_1005Metric; not fitted
R19, R20, R21, R27, R44, R63: 4k7; R_0402_1005Metric
U1: XC7A50T-FGG484; Xilinx_FGG484
U7: MT25QL128ABA1EW7-0SIT; W-PDFN-8-1EP_6x5mm_P1.27mm_EP3x3mm; MPN MT25QL128ABA1EW7-0SIT; LCSC C2887898

Connections:
+3V3: C111.1, C150.1, C151.1, D1.2 (A), R2.1, R15.1, R19.1, R20.1, R21.1, R27.2, R44.2, R63.2, U1.F12 (VCCO_0), U1.T12 (VCCO_0), U1.U8 (CFGBVS_0), U7.8 (VCC); also elsewhere on the board
/Artix 7 Banks/QSPI_CS: R19.2, U7.1 (~S); also elsewhere on the board
/Artix 7 Banks/QSPI_DQ0: U7.5 (DQ0); also elsewhere on the board
/Artix 7 Banks/QSPI_DQ1: U7.2 (DQ1); also elsewhere on the board
/Artix 7 Banks/QSPI_DQ2: R20.2, U7.3 (~W/DQ2); also elsewhere on the board
/Artix 7 Banks/QSPI_DQ3: R21.2, U7.7 (~RESET/DQ3); also elsewhere on the board
/Artix 7 Configurations and Flash/DONE: R24.1, R63.1, U1.G11 (DONE_0)
/Artix 7 Configurations and Flash/JTAG_TCK: U1.V12 (TCK_0); also elsewhere on the board
/Artix 7 Configurations and Flash/JTAG_TDI: U1.R13 (TDI_0); also elsewhere on the board
/Artix 7 Configurations and Flash/JTAG_TDO: U1.U13 (TDO_0); also elsewhere on the board
/Artix 7 Configurations and Flash/JTAG_TMS: U1.T13 (TMS_0); also elsewhere on the board
/Artix 7 Configurations and Flash/QSPI_CLK: U1.L12 (CCLK_0), U7.6 (C)
GND: C111.2, C150.2, C151.2, R3.2, R14.2, U1.L9 (VREFN_0), U1.L10 (VP_0), U1.M9 (VN_0), U1.M10 (VREFP_0), U1.N9 (DXN_0), U1.N10 (DXP_0), U7.4 (VSS), U7.9 (PAD); also elsewhere on the board
unnamed: D1.1 (K), R24.2
unnamed: R27.1, U1.U12 (INIT_B_0)
unnamed: R2.2, U1.U11 (M0_0)
unnamed: R14.1, U1.U10 (M1_0)
unnamed: R3.1, R15.2, U1.U9 (M2_0)
unnamed: R44.1, U1.N12 (PROGRAM_B_0)

Notes on the sheet:
< Optional for JTAG w/ built in artix memory
Bank 14/15 need to be 3V3 because of CFGBVS
< Master SPI M[2:0] 001
< No temp sense, no internals, tying low (UG475)
< DONE sinks current, LED turns off when done

Board: 6 copper layers, 22.0 x 80.0 mm, 277 parts (196 on the bottom side), 193 nets.

File PCB/production/BOM_LCSC.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C10, C11, C12, C3, C4, C5, C6, C7, C8, C9",402,10,220n,C16772
"C100, C102, C104, C105, C106, C107, C108, C109, C112, C118, C124, C125, C127, C129, C135, C136, C137, C138, C143, C144, C145, C146, C148, C150, C151, C154, C155, C156, C157, C161, C162, C163, C164, C168, C169, C17, C170, C171, C18, C19, C20, C25, C27, C28, C29, C30, C31, C35, C36, C38, C39, C47, C54, C67, C69, C71, C91, C92, C95, C99",201,60,470n,C76591
"C101, C103, C126, C130, C133, C134, C141, C142, C147, C15, C152, C153, C159, C160, C166, C167, C173, C2, C21, C22, C23, C32, C33, C37, C40, C41, C42, C43, C44, C56, C66, C68, C70, C75, C87, C89, C90, C94, C98",603,39,4u7,C19666
"C110, C111, C113, C114, C115, C116, C117, C119, C120, C122, C123, C139, C14, C16, C57, C58, C59, C60, C61, C62, C63, C64, C65, C73, C74, C76, C77, C78, C79, C80, C81, C82, C83, C84, C86, C93",402,36,100n,C1525
"C121, C46",402,2,1u,C52923
"C128, C72",603,2,47n,C1622
"C13, C172",402,2,10n,C15195
"C131, C132, C140, C149, C158, C165, C34, C45, C49, C51, C53, C85, C88",1206,13,47u,C96123
C24,CP_EIA-3528-21_Kemet-B,1,330u,C542287
C26,1206,1,100u,C15008
C48,402,1,68pF,C107009
"C50, C96, C97",402,3,33p,C1562
C52,402,1,22pF,C1555
D1,603,1,KT-0603R,C2296
D2,805,1,KT-0805Y,C2296
D3,D_SOD-323,1,1N5819WS,1N5819WS
"D4, D5, D6, D7",603,4,KT-0603G,C2297
FB1,805,1,120@100MHz,C5120901
J1,M.2 M-Key 2242,1,Bus_M.2_Edge_M,
J4,USB_C_Receptacle_HRO_TYPE-C-31-M-12,1,TYPE-C-31-M-12,C165948
J5,PinHeader_2x05_P1.27mm_Vertical_SMD,1,Conn_02x05_Odd_Even,C41376037
J7,Kai's_HDMI_Micro-D_Molex_46765-1xxx,1,HDMI_D_1.4,C711358
"L1, L2, L3, L4, L5, L6",L_Sunlord_SWPA4030S,6,1u5,C42100
"R1, R31",402,2,100,C25076
"R10, R11, R12, R13, R34, R38, R39, R40, R41, R45, R46, R5, R50, R51, R53, R54, R7, R9",402,18,10k,C25744
"R14, R15, R17, R18, R2, R24, R3, R42, R43, R56, R57, R76, R77, R78, R79, R80",402,16,1k,C11702
R16,402,1,240,C25153
"R19, R20, R21, R23, R27, R28, R30, R44, R59, R60, R61, R62, R63",402,13,4k7,C25900
"R25, R26, R29, R32, R36, R37, R75",402,7,22,C25092
"R33, R47",603,2,30k,C22984
"R35, R6",603,2,4k99,C23046
R4,402,1,2k,C4109
"R48, R49",402,2,5k1,C25905
R52,402,1,2k2,C25879
R55,402,1,12k,C25752
"R58, R65",402,2,100k,C25741
R8,603,1,8k2,C25981
U1,Xilinx_FGG484,1,XC7A50T-FGG484,C1521780
U10,QFN-64-1EP_9x9mm_P0.5mm_EP4.35x4.35mm,1,FT2232HQ,C193662
U11,FBGA-96_8x14mm_Layout9x16_P0.8mm,1,MT41J128M16JT-125:K,C426885
U12,VSSOP-8_2.3x2mm_P0.5mm,1,PCA9306DC1,C129510
"U14, U15, U16",Diodes_UDFN-10_1.0x2.5mm_P0.5mm,3,UCL0524P,C2835428
U17,VQFN-16-1EP_3x3mm_P0.5mm_EP1.68x1.68mm_ThermalVias,1,TPS62132,C81563
U2,QFN-28-1EP_5x5mm_P0.5mm_EP3.25x3.25mm_ThermalVias,1,MAX20029ATIA/V+,C1235515
"U3, U4, U6",Texas_DRT-3,3,TPD2EUSB30,C97502
U5,Texas_VQFN-HR-12_2x2.5mm_P0.5mm_ThermalVias,1,TPS2121RUXR,C485916
U7,W-PDFN-8-1EP_6x5mm_P1.27mm_EP3x3mm,1,MT25QL128ABA1EW7-0SIT,C2887898
U8,WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm,1,TPS61240DRVR,C59567
U9,SOIC-8_3.9x4.9mm_P1.27mm,1,M93C56-WMN6TP,C283453
Y2,Crystal_SMD_3225-4Pin_3.2x2.5mm,1,12MHz,C9002
Y3,Oscillator_SMD_SiT_PQFN-4Pin_5.0x3.2mm,1,100MHz,C78882
