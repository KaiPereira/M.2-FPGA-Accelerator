File: PCB/ddr3l.kicad_sch (KiCad schematic)
At the start: 6 parts, among them U11 MT41J128M16JT-125:K

Commit message: separated RAM IC power/ground pins and signals
Parts:
- added unit 2 of U11
Connections:
- net +1V5: no longer U11.A1 (V_{DDQ}), U11.A8 (V_{DDQ}), U11.B2 (V_{DD}), U11.C1 (V_{DDQ}), U11.C9 (V_{DDQ}), U11.D2 (V_{DDQ}), U11.D9 (V_{DD}), U11.E9 (V_{DDQ}), U11.F1 (V_{DDQ}), U11.G7 (V_{DD}), U11.H2 (V_{DDQ}), U11.H9 (V_{DDQ})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
- net GND: no longer U11.A9 (V_{SS}), U11.B1 (V_{SSQ}), U11.B3 (V_{SS}), U11.B9 (V_{SSQ}), U11.D1 (V_{SSQ}), U11.D8 (V_{SSQ}), U11.E1 (V_{SS}), U11.E2 (V_{SSQ}), U11.E8 (V_{SSQ}), U11.F9 (V_{SSQ}), U11.G1 (V_{SSQ}), U11.G8 (V_{SS})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
Other:
- note removed: "< Check phils lab for RC filter on Q pins?"

Commit message: decoupling DDR and more VREF decoupling
Parts:
- added C110, C86: 10n, symbol Device:C
- added C59, C60, C61, C62, C63, C64, C65, C73, C74, C76, C77, C78, C79, C80, C81, C82, C83, C84: 100n, symbol Device:C
- added C75, C85: 47u, symbol Device:C
Connections:
- net +1V5: now also U11.A1 (V_{DDQ}), U11.A8 (V_{DDQ}), U11.B2 (V_{DD}), U11.C1 (V_{DDQ}), U11.C9 (V_{DDQ}), U11.D2 (V_{DDQ}), U11.D9 (V_{DD}), U11.E9 (V_{DDQ}), U11.F1 (V_{DDQ}), U11.G7 (V_{DD}), U11.H2 (V_{DDQ}), U11.H9 (V_{DDQ})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
- net GND: now also U11.A9 (V_{SS}), U11.B1 (V_{SSQ}), U11.B3 (V_{SS}), U11.B9 (V_{SSQ}), U11.D1 (V_{SSQ}), U11.D8 (V_{SSQ}), U11.E1 (V_{SS}), U11.E2 (V_{SSQ}), U11.E8 (V_{SSQ}), U11.F9 (V_{SSQ}), U11.G1 (V_{SSQ}), U11.G8 (V_{SS})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
- net at C57.2, C58.1, R17.2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: now also C110.1, C86.2
Other:
- note added: "< BOM optimize to 47n?"
- moved on the sheet: C57, C58, R16, R17, R18, U11A

Commit message: some footprints added in, starting to work on flash
Other:
- note added: "PULLDOWNS???"
Changed lines of the file:
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@@
+		)
+	)
+	(text "PULLDOWNS???"
+		(exclude_from_sim no)
+		(at 44.958 222.25 0)
+		(effects
+			(font
+				(size 2.54 2.54)
+			)
 		)
 	)

Commit message: added some configuration features and cleaned it up
Other:
- note added: "PULLDOWNS on commands???"
- note removed: "PULLDOWNS???"
Changed lines of the file:
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@@
 		)
 	)
-	(text "PULLDOWNS???"
+	(text "PULLDOWNS on commands???"
 		(exclude_from_sim no)
-		(at 44.958 222.25 0)
+		(at 53.848 224.536 0)
 		(effects
 			(font

Commit message: finished DDR wiring
Parts:
- added R23, R28, R30: 4k7, symbol Device:R
- added R31, R42: 100, symbol Device:R
Connections:
- net DDR_CKE: now also R30.1
- net DDR_CLK+: now also R31.1
- net DDR_CLK-: now also R31.2
- net GND: now also R23.2, R28.2, R30.2, R42.1
- net ~{DDR_ODT}: now also R23.1
- net ~{DDR_RESET}: now also R28.1
- net ~{DDR_CS}: no longer names the net of U11.L2 (~{CS})
- net ~{DDR_CS}: now also R42.2
Other:
- note added: "< 0.75V reference, needs to be very precise!"
- note added: "Shunt termination because CLK doesn't have ODT :("
- note removed: "< BOM optimize to 47n?"
- note removed: "DECOUPLING"
- note removed: "PULLDOWNS on commands???"
- moved on the sheet: C110, C57, C58, C59, C60, C61, C62, C63, C64, C65, C73, C74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
